PHPVERSION = "70"

require composer.inc

SRC_URI[sha256sum] = "060ff6b6b8bfb60a943c94954cc4e8bf3e780ff33ecd7c7d9eb2f43241f39740"
