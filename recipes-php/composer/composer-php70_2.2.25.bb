PHPVERSION = "70"

require composer.inc

SRC_URI[sha256sum] = "8b3f41253363f0645402d1951d6e7f02adedeef29c16de6074763e463e25c23f"
