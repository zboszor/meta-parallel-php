PHPVERSION = "71"

require composer.inc

PV = "2.2.29"
SRC_URI[sha256sum] = "f38623ebdeeab5905b24b048fd32804150e598436cc43db9fc12362894c1279d"
