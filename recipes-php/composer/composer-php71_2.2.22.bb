PHPVERSION = "71"

require composer.inc

SRC_URI[sha256sum] = "7d3500cc8c9a74b47e14103de150ac95c25ca227b39ffc89cb3a8b495b5db1d2"
