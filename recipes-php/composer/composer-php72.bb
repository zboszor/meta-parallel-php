PHPVERSION = "72"

require composer.inc
