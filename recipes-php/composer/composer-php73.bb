PHPVERSION = "73"

require composer.inc
