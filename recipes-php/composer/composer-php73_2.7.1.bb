PHPVERSION = "73"

require composer.inc

SRC_URI[sha256sum] = "1ffd0be3f27e237b1ae47f9e8f29f96ac7f50a0bd9eef4f88cdbe94dd04bfff0"
