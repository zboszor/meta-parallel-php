PHPVERSION = "73"

require composer.inc

SRC_URI[sha256sum] = "b6de5e65c199d80ba11897fbe1364e063e858d483f6a81a176c4d60f2b1d6347"
