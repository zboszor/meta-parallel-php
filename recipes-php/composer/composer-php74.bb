PHPVERSION = "74"

require composer.inc
