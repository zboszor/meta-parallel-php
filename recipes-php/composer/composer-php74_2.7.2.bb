PHPVERSION = "74"

require composer.inc

SRC_URI[sha256sum] = "049b8e0ed9f264d770a0510858cffbc35401510759edc9a784b3a5c6e020bcac"
