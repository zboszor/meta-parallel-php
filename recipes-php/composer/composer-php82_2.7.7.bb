PHPVERSION = "82"

require composer.inc

SRC_URI[sha256sum] = "aab940cd53d285a54c50465820a2080fcb7182a4ba1e5f795abfb10414a4b4be"
