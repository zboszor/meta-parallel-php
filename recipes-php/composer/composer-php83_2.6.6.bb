PHPVERSION = "83"

require composer.inc

SRC_URI[sha256sum] = "72600201c73c7c4b218f1c0511b36d8537963e36aafa244757f52309f885b314"
