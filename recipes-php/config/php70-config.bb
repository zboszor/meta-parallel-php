PHPVERSION = "70"

require php-config.inc
