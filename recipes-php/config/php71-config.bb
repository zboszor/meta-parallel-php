PHPVERSION = "71"

require php-config.inc
