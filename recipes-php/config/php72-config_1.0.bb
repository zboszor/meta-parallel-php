PHPVERSION = "72"

require php-config.inc
