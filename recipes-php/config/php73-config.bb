PHPVERSION = "73"

require php-config.inc
