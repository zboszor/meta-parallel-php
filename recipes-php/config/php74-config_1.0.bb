PHPVERSION = "74"

require php-config.inc
