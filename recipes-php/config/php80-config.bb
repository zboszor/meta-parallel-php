PHPVERSION = "80"

require php-config.inc
