PHPVERSION = "82"

require php-config.inc
