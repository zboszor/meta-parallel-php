PHPVERSION = "83"

require php-config.inc
