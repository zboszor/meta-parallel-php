PHPVERSION = "84"

require php-config.inc
