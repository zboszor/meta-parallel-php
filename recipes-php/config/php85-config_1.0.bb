PHPVERSION = "85"

require php-config.inc
