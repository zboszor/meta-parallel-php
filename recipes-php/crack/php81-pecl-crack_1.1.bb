require php-pecl-crack.inc

PHPVERSION = "81"

SRCREV = "dd0699635f389fd8d4875ed8b5bc37b99ab2fe58"
