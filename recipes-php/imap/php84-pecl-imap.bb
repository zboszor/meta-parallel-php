require php-pecl-imap.inc

PHPVERSION = "84"
