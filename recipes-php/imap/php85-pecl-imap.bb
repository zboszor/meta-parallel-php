require php-pecl-imap.inc

PHPVERSION = "85"
