require php-pecl-inotify.inc

PHPVERSION = "72"
