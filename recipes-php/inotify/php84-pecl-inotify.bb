require php-pecl-inotify.inc

PHPVERSION = "84"
