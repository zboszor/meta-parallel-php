require php-pecl-mcrypt.inc

PHPVERSION = "72"
