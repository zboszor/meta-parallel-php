require php-pecl-mcrypt.inc

PHPVERSION = "81"
