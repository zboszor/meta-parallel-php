require php-pecl-mcrypt.inc

PHPVERSION = "84"
