require php-nano.inc

PHPVERSION = "70"
