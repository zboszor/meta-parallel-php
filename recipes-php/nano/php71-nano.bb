require php-nano.inc

PHPVERSION = "71"
