require php-nano.inc

PHPVERSION = "80"
