PHPVERSION = "70"

require php-pecl-ncurses.inc
