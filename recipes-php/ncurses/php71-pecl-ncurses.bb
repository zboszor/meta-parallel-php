PHPVERSION = "71"

require php-pecl-ncurses.inc
