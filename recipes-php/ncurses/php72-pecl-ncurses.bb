PHPVERSION = "72"

require php-pecl-ncurses.inc
