PHPVERSION = "73"

require php-pecl-ncurses.inc
