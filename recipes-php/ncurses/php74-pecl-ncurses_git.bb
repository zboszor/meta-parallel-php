PHPVERSION = "74"

require php-pecl-ncurses.inc
