PHPVERSION = "80"

require php-pecl-ncurses.inc
