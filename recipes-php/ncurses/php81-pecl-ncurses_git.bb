PHPVERSION = "81"

require php-pecl-ncurses.inc
