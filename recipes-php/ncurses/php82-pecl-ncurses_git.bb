PHPVERSION = "82"

require php-pecl-ncurses.inc
