PHPVERSION = "83"

require php-pecl-ncurses.inc
