PHPVERSION = "84"

require php-pecl-ncurses.inc
