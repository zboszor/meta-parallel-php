PHPVERSION = "85"

require php-pecl-ncurses.inc
