require php-opencreports.inc

PHPVERSION = "70"
