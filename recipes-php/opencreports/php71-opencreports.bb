require php-opencreports.inc

PHPVERSION = "71"
