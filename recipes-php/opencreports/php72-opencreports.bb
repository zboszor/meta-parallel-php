require php-opencreports.inc

PHPVERSION = "72"
