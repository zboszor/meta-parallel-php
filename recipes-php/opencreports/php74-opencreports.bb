require php-opencreports.inc

PHPVERSION = "74"
