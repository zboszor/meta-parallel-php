require php-pecl-pam.inc

PHPVERSION = "84"
