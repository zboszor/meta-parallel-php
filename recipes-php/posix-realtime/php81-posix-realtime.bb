require php-posix-realtime.inc

PHPVERSION = "81"
