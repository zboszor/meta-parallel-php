require php-posix-realtime.inc

PHPVERSION = "82"
