require php-screw.inc

PHPVERSION = "70"
