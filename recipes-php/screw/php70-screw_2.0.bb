require php-screw.inc
PHPVERSION = "70"
#PR = "r1"
SRCREV = "d40f813e16033d5ce6d3762fab5db94e52cc9295"
inherit parallel-php-module
