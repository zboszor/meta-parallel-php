require php-screw.inc
PHPVERSION = "73"
#PR = "r1"
SRCREV = "55c0f77ecd591726d251f15d0d28f59bf99a3c4f"
inherit parallel-php-module
