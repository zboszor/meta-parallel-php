require php-screw.inc
PHPVERSION = "80"
#PR = "r1"
SRCREV = "970ec8107e9d1cc59b38e37bd55146c198f4813f"
inherit parallel-php-module
