require php-screw.inc
PHPVERSION = "80"
#PR = "r1"
SRCREV = "fb482a7c4aad09a8129c6b21382fd08a8887f1e6"
inherit parallel-php-module
