require php-screw.inc
PHPVERSION = "84"
#PR = "r1"
SRCREV = "0929fface981feeae1a8fce599723308e4d04165"
inherit parallel-php-module
