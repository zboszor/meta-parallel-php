require php-pecl-ssh2.inc

PV = "1.4.1"
SRC_URI[sha256sum] = "7bca5b23f731db9d8ed0aea5db9bb15da8ff133b0fbba96102b82e95da4d8764"

PHPVERSION = "74"
