DESCRIPTION = "Symlinks for PHP 7.0"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "70"
