DESCRIPTION = "Symlinks for PHP 7.1"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "71"
