DESCRIPTION = "Symlinks for PHP 7.2"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "72"
