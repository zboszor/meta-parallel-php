DESCRIPTION = "Symlinks for PHP 7.3"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "73"
