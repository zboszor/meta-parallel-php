DESCRIPTION = "Symlinks for PHP 7.4"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "74"
