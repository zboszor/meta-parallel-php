DESCRIPTION = "Symlinks for PHP 8.1"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "81"
