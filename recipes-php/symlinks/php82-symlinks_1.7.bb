DESCRIPTION = "Symlinks for PHP 8.2"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "82"
