DESCRIPTION = "Symlinks for PHP 8.3"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "83"
