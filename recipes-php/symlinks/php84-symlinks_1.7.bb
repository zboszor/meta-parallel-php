DESCRIPTION = "Symlinks for PHP 8.4"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "84"
