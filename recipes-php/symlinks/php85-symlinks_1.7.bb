DESCRIPTION = "Symlinks for PHP 8.5"

require php-symlinks.inc

#PR = "r1"

PHPVERSION = "85"
