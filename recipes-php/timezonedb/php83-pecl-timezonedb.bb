require php-pecl-timezonedb.inc

PHPVERSION = "83"
