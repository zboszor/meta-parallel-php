require php-pecl-xdebug.inc

PHPVERSION = "81"
