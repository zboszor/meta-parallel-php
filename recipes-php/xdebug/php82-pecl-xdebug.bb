require php-pecl-xdebug.inc

PHPVERSION = "82"
