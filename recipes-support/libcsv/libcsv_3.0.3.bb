DESCRIPTION = "Fast and flexible CSV library written in pure ANSI C that can read and write CSV data."
HOMEPAGE = "https://github.com/rgamble/libcsv"
LICENSE = "LGPL-2.1-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=286c772587353199989bea3d935e1718"

SRC_URI = "git://github.com/rgamble/libcsv;protocol=https;branch=master"
SRCREV = "b1d5212831842ee5869d99bc208a21837e4037d5"

inherit autotools
