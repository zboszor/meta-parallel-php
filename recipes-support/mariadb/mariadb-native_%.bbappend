FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://rocksdb-add-cstdint.patch"
